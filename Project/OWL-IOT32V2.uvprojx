# Keil uVision project OWL-IOT32V2.uvprojx, settings and files
target OWL-IOT32V2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OWL-IOT32V2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\user;..\user\Led_driver;..\user\TIM_driver;..\user\RCC;..\user\SysTick;..\user\BEEP;..\user\USART;..\user\ST_string;..\user\SPI;..\user\OLED_Device;..\user\I2C;..\user\EEPROM;..\user\dht11;..\user\adc;..\user\STM32_ChipID;..\user\Data_Structure;..\user\Data_Structure\SeqQueue;..\user\Run_task;..\user\key;..\user\SPIFlash;..\user\RC522;..\user\BMA250E;..\user\BMA2x2_driver;..\user\RTL8710_driver;..\user\Data_Structure\pipe;..\user\TLSR8266_driver;..\user\Bluetooth;..\user\TimeOut;..\user\Data_pack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
  group Libraries
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ST_string
    ../user/ST_string/: ST_string.c
  group BSP
    ../user/RCC/: sys_rcc.c
    ../user/SysTick/: SysTick.c
    ../user/STM32_ChipID/: STM32_ChipID.c
    ../user/TIM_driver/: TIM_driver.c
    ../user/Led_driver/: Led_driver.c
    ../user/BEEP/: beep_driver.c
    ../user/USART/: usart_driver.c
    ../user/SPI/: spi_driver.c
    ../user/I2C/: i2c_driver.c
    ../user/adc/: adc_driver.c
    ../user/OLED_Device/: OLED_Device.c
    ../user/EEPROM/: eeprom.c
    ../user/dht11/: dht11_driver.c
    ../user/key/: key_driver.c
    ../user/SPIFlash/: spiflash_driver.c
    ../user/RC522/: rc522_driver.c
    ../user/BMA250E/: bma250e_driver.c
    ../user/BMA2x2_driver/: bma2x2.c bma2x2_support.c
    ../user/RTL8710_driver/: RTL8710_driver.c
    ../user/TLSR8266_driver/: tlsr8266_ble_driver.c
    ../user/Bluetooth/: Bluetooth.c
  group Data_Structure
    ../user/Data_Structure/: Data_Structure.c
    ../user/Data_Structure/SeqQueue/: SeqList.c SeqQueue.c
    ../user/Data_Structure/pipe/: pipe.c
    ../user/TimeOut/: TimeOut.c
  group Data_Pack
    ../user/Data_pack/: data_pack.c
  group Run_task
    ../user/Run_task/: Run_task.c
  group User
    ../user/: main.c stm32f10x_it.c board_config.h
  group Doc
    ../Doc/: ReadMe.txt
